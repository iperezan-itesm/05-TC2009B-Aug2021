# Keil uVision project example01_addition.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: example01_addition
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ../../../../source_codes/s/cortex-m0p/startup_files/: startup_MKL25Z4.s system_MKL25Z4.c system_MKL25Z4.h
